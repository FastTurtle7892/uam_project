options:
  parameters:
    author: Barry Duggan
    description: Station control module
    generate_options: qt_gui
    id: xmt_rcv_switch
    output_language: python
    title: xmt_rcv_switch
  states: {}

blocks:
- name: burst_key
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    comment: 9,0
    gui_hint: 9,0,1,1
    label: Receive Freq
    type: real
    value: '5120000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: 1,0
    gui_hint: 1,0,1,3
    label: Rcv Gain
    start: '0'
    step: '1'
    stop: '76'
    value: '76'
    widget: slider
  states: {}
- name: offset
  id: variable_qtgui_chooser
  parameters:
    comment: 9,1
    gui_hint: 9,1,1,1
    label: Offset
    labels: '["-5MHz", "-600kHz", "0", "+600kHz", "+5MHz"]'
    num_opts: '0'
    options: '[-5000000, -600000, 0, 600000, 5000000]'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: state
  id: variable_qtgui_toggle_button_msg
  parameters:
    comment: 10,2
    gui_hint: 10,2,1,1
    initPressed: 'False'
    label: Transmit
    pressBackgroundColor: red
    pressFontColor: black
    pressed: '1'
    relFontColor: black
    released: '0'
    type: int
    value: '0'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: freq+offset
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: 2,0
    gui_hint: 2,0,1,3
    label: Tx gain
    start: '0'
    step: '0.1'
    stop: '1.00'
    value: '1.00'
    widget: slider
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    comment: 9,2
    gui_hint: 9,2,1,1
    label: Transmit Freq
    type: real
    value: tx_freq
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    comment: burst_key
    const: burst_key
    type: short
  states: {state: disabled}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: tx_eob
    false_value: 'True'
    true_key: tx_sob
    true_value: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: burst_key
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: 'False'
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nTransmit / Receive Controller\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pmt\n\nclass blk(gr.sync_block):\n    \"\"\"\n    reads input from a message port\n    generates control messages\n    \"\"\"\n    def __init__(self):\n        gr.sync_block.__init__(self,\n            name='XMT/RCV Control',   # will show up in GRC\n            in_sig=None,\n            out_sig=None)\n        self.message_port_register_in(pmt.intern('msg_in'))\n        self.message_port_register_out(pmt.intern('burst'))\n        self.message_port_register_out(pmt.intern('tx_mute'))\n        self.message_port_register_out(pmt.intern('rx_led'))\n        self.message_port_register_out(pmt.intern('ant_sw'))\n        self.message_port_register_out(pmt.intern('sw_cmd'))\n        self.message_port_register_out(pmt.intern('pa_sw'))\n        self.message_port_register_out(pmt.intern('rx_mute'))\n        self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)\n\n    def handle_msg(self, msg):\n        _debug = 0          # set to zero to turn off diagnostics\n\n        try:\n            new_val = pmt.to_python(pmt.cdr(msg))\n        except Exception as e:\n            gr.log.error(\"Error with message conversion: %s\" % str(e))\n        if (_debug):\n            print (\"new_val =\", new_val)\n        if (new_val == 1):\n\n            # (1) mute receive\n            if (_debug):\n                print (\"t1\")\n            self.message_port_pub(pmt.intern('rx_mute'), pmt.to_pmt(True))\n\n            # (2) turn off rcv LED\n            if (_debug):\n                print (\"t2\")\n            self.message_port_pub(pmt.intern('rx_led'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_bool(False)))\n\n            # (3) send message to relay_sequencer\n            if (_debug):\n                print (\"t3\")\n            self.message_port_pub(pmt.intern('sw_cmd'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_long(1)))\n\n            # (4) turn on Antenna LED\n            if (_debug):\n                print (\"t4\")\n            self.message_port_pub(pmt.intern('ant_sw'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_bool(True)))\n\n        elif (new_val == 3):\n\n            # (9) turn on Amp LED\n            if (_debug):\n                print (\"t9\")\n            self.message_port_pub(pmt.intern('pa_sw'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_bool(True)))\n\n            # (10) delay 10 ms\n            time.sleep (0.01)\n\n            # (11) unmute transmit (enable Selector)\n            if (_debug):\n                print (\"t11\")\n            self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(True))\n\n            # (12) send message to burst tagger\n            if (_debug):\n                print (\"t12\")\n            self.message_port_pub(pmt.intern('burst'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_long(1)))\n\n        elif (new_val == 0):\n\n            # (12) send message to burst tagger\n            if (_debug):\n                print (\"t12\")\n            self.message_port_pub(pmt.intern('burst'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_long(0)))\n\n            # (11.5) delay 5 ms\n            time.sleep (0.005)\n\n            # (11) mute transmit (disable Selector)\n            if (_debug):\n                print (\"r11\")\n            self.message_port_pub(pmt.intern('tx_mute'), pmt.to_pmt(False))\n\n            # (10) send message to relay_sequencer\n            if (_debug):\n                print (\"r10\")\n            self.message_port_pub(pmt.intern('sw_cmd'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_long(0)))\n\n            # (9) turn off Amp LED\n            if (_debug):\n                print (\"r9\")\n            self.message_port_pub(pmt.intern('pa_sw'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_bool(False)))\n\n        elif (new_val == 2):\n\n            # (4) turn off Antenna LED\n            if (_debug):\n                print (\"r4\")\n            self.message_port_pub(pmt.intern('ant_sw'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_bool(False)))\n\n            # (3) delay 10 ms\n            time.sleep (0.01)\n\n            # (2) turn on rcv LED\n            if (_debug):\n                print (\"r2\")\n            self.message_port_pub(pmt.intern('rx_led'),\n                pmt.cons(pmt.intern('pressed'),\n                pmt.from_bool(True)))\n\n            # unmute receive\n            if (_debug):\n                print (\"r1\")\n            self.message_port_pub(pmt.intern('rx_mute'), pmt.to_pmt(False))\n\n\n"
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    cellalignment: '2'
    gui_hint: 0,1,1,1
    label: '"Antenna"'
    offColor: lime
    onColor: yellow
  states: {}
- name: qtgui_ledindicator_1
  id: qtgui_ledindicator
  parameters:
    cellalignment: '2'
    gui_hint: 0,2,1,1
    label: '"Power Amp"'
    offColor: gray
    onColor: red
  states: {}
- name: qtgui_ledindicator_2
  id: qtgui_ledindicator
  parameters:
    cellalignment: '2'
    gui_hint: 0,0,1,1
    label: '"Receive"'
    offColor: gray
    onColor: lime
    state: 'True'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 3,0,1,3
    nconnections: '2'
    size: '32768'
    srate: samp_rate
    tr_chan: '1'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"tx_eob"'
    type: complex
    ymax: '1.5'
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: '200000'
    center_freq0: uhd.tune_request(tx_freq, 300000)
    clock_rate: 30.72e6
    dev_addr: serial = 321CAE2
    dev_args: '"send_frame_size=8192,num_send_frames=128"'
    gain0: tx_gain
    gain_type0: normalized
    len_tag_name: ''
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: uhd.tune_request(freq, 180000)
    clock_rate: 30.72e6
    dev_addr: serial=3218CC8
    dev_args: '"recv_buff_size=12352,recv_frame_size=1544"'
    gain0: gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:49202
    timeout: '100'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49201
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:49204
    timeout: '100'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49203
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', blocks_burst_tagger_0, '1']
- [analog_const_source_x_0, '0', blocks_short_to_float_0, '0']
- [blocks_burst_tagger_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_burst_tagger_0, '0', uhd_usrp_sink_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_mute_xx_0, '0', zeromq_pub_sink_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_selector_0, '0', blocks_burst_tagger_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [epy_block_0, ant_sw, qtgui_ledindicator_0, state]
- [epy_block_0, burst, blocks_msgpair_to_var_0, inpair]
- [epy_block_0, pa_sw, qtgui_ledindicator_1, state]
- [epy_block_0, rx_led, qtgui_ledindicator_2, state]
- [epy_block_0, rx_mute, blocks_mute_xx_0, set_mute]
- [epy_block_0, sw_cmd, zeromq_pub_msg_sink_0, in]
- [epy_block_0, tx_mute, blocks_selector_0, en]
- [state, state, epy_block_0, msg_in]
- [uhd_usrp_source_0, '0', blocks_mute_xx_0, '0']
- [zeromq_sub_msg_source_0, out, epy_block_0, msg_in]
- [zeromq_sub_source_0, '0', blocks_selector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
